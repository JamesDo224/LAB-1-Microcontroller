# file: LAB_1_STM32_Project.ioc
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Mcu.Family=STM32F1
Mcu.Name=STM32F103C6Ux
Mcu.Package=UFQFPN48
NVIC.PriorityGroup=NVIC_PRIORITYGROUP_4
ProjectManager.HeapSize=0x200
ProjectManager.StackSize=0x400
ProjectManager.TargetToolchain=STM32CubeIDE
RCC.APB1Freq_Value=8000000
RCC.APB2Freq_Value=8000000
VP_SYS_VS_ND.Mode=No_Debug
board=custom

// file: Core/Src/main.c
/* USER CODE BEGIN Header */
/**
  ******************************************************************************
  * @file           : main.c
  * @brief          : Main program body
  ******************************************************************************
  * @attention
  *
  * <h2><center>&copy; Copyright (c) 2024 STMicroelectronics.
  * All rights reserved.</center></h2>
  *
  * This software component is licensed by ST under BSD 3-Clause license,
  * the "License"; You may not use this file except in compliance with the
  * License. You may obtain a copy of the License at:
  *                        opensource.org/licenses/BSD-3-Clause
  *
  ******************************************************************************
  */
/* USER CODE END Header */
#include "main.h"

void SystemClock_Config(void);
static void MX_GPIO_Init(void);

int main(void)
{

  /* MCU Configuration--------------------------------------------------------*/

  /* Reset of all peripherals, Initializes the Flash interface and the Systick. */
  HAL_Init();

  /* Configure the system clock */
  SystemClock_Config();

  /* Initialize all configured peripherals */
  MX_GPIO_Init();

  /* Infinite loop */
  /* USER CODE BEGIN WHILE */
  void display7SEG(int num)
  {
	  switch(num){
	  case 0:
	   	  HAL_GPIO_WritePin(A_GPIO_Port, A_Pin, RESET);
	   	  HAL_GPIO_WritePin(B_GPIO_Port, B_Pin, RESET);
	   	  HAL_GPIO_WritePin(C_GPIO_Port, C_Pin, RESET);
	   	  HAL_GPIO_WritePin(D_GPIO_Port, D_Pin, RESET);
	   	  HAL_GPIO_WritePin(E_GPIO_Port, E_Pin, RESET);
	   	  HAL_GPIO_WritePin(F_GPIO_Port, F_Pin, RESET);
	   	  HAL_GPIO_WritePin(G_GPIO_Port, G_Pin, SET);
	   	  break;
	  case 1:
		  HAL_GPIO_WritePin(A_GPIO_Port, A_Pin, SET);
		  HAL_GPIO_WritePin(B_GPIO_Port, B_Pin, RESET);
	  	  HAL_GPIO_WritePin(C_GPIO_Port, C_Pin, RESET);
	  	  HAL_GPIO_WritePin(D_GPIO_Port, D_Pin, SET);
	  	  HAL_GPIO_WritePin(E_GPIO_Port, E_Pin, SET);
	  	  HAL_GPIO_WritePin(F_GPIO_Port, F_Pin, SET);
	  	  HAL_GPIO_WritePin(G_GPIO_Port, G_Pin, SET);
	  	  break;
	  case 2:
	  	  HAL_GPIO_WritePin(A_GPIO_Port, A_Pin, RESET);
	  	  HAL_GPIO_WritePin(B_GPIO_Port, B_Pin, RESET);
	  	  HAL_GPIO_WritePin(C_GPIO_Port, C_Pin, SET);
	  	  HAL_GPIO_WritePin(D_GPIO_Port, D_Pin, RESET);
	  	  HAL_GPIO_WritePin(E_GPIO_Port, E_Pin, RESET);
	  	  HAL_GPIO_WritePin(F_GPIO_Port, F_Pin, SET);
	  	  HAL_GPIO_WritePin(G_GPIO_Port, G_Pin, RESET);
	  	  break;
	  case 3:
	  	  HAL_GPIO_WritePin(A_GPIO_Port, A_Pin, RESET);
	  	  HAL_GPIO_WritePin(B_GPIO_Port, B_Pin, RESET);
	  	  HAL_GPIO_WritePin(C_GPIO_Port, C_Pin, RESET);
	  	  HAL_GPIO_WritePin(D_GPIO_Port, D_Pin, RESET);
	  	  HAL_GPIO_WritePin(E_GPIO_Port, E_Pin, SET);
	  	  HAL_GPIO_WritePin(F_GPIO_Port, F_Pin, SET);
	  	  HAL_GPIO_WritePin(G_GPIO_Port, G_Pin, RESET);
	  	  break;
	  case 4:
	  	  HAL_GPIO_WritePin(A_GPIO_Port, A_Pin, SET);
	  	  HAL_GPIO_WritePin(B_GPIO_Port, B_Pin, RESET);
	   	  HAL_GPIO_WritePin(C_GPIO_Port, C_Pin, RESET);
	  	  HAL_GPIO_WritePin(D_GPIO_Port, D_Pin, SET);
	  	  HAL_GPIO_WritePin(E_GPIO_Port, E_Pin, SET);
	   	  HAL_GPIO_WritePin(F_GPIO_Port, F_Pin, RESET);
	   	  HAL_GPIO_WritePin(G_GPIO_Port, G_Pin, RESET);
	   	  break;
	  case 5:
	   	  HAL_GPIO_WritePin(A_GPIO_Port, A_Pin, RESET);
	   	  HAL_GPIO_WritePin(B_GPIO_Port, B_Pin, SET);
	   	  HAL_GPIO_WritePin(C_GPIO_Port, C_Pin, RESET);
	   	  HAL_GPIO_WritePin(D_GPIO_Port, D_Pin, RESET);
	   	  HAL_GPIO_WritePin(E_GPIO_Port, E_Pin, SET);
	   	  HAL_GPIO_WritePin(F_GPIO_Port, F_Pin, RESET);
	   	  HAL_GPIO_WritePin(G_GPIO_Port, G_Pin, RESET);
	   	  break;
	  case 6:
	 	  HAL_GPIO_WritePin(A_GPIO_Port, A_Pin, RESET);
	  	  HAL_GPIO_WritePin(B_GPIO_Port, B_Pin, SET);
	  	  HAL_GPIO_WritePin(C_GPIO_Port, C_Pin, RESET);
	  	  HAL_GPIO_WritePin(D_GPIO_Port, D_Pin, RESET);
	  	  HAL_GPIO_WritePin(E_GPIO_Port, E_Pin, RESET);
	  	  HAL_GPIO_WritePin(F_GPIO_Port, F_Pin, RESET);
	  	  HAL_GPIO_WritePin(G_GPIO_Port, G_Pin, RESET);
	  	  break;
	  case 7:
	 	  HAL_GPIO_WritePin(A_GPIO_Port, A_Pin, RESET);
	  	  HAL_GPIO_WritePin(B_GPIO_Port, B_Pin, RESET);
	  	  HAL_GPIO_WritePin(C_GPIO_Port, C_Pin, RESET);
	  	  HAL_GPIO_WritePin(D_GPIO_Port, D_Pin, SET);
	  	  HAL_GPIO_WritePin(E_GPIO_Port, E_Pin, SET);
	   	  HAL_GPIO_WritePin(F_GPIO_Port, F_Pin, SET);
	  	  HAL_GPIO_WritePin(G_GPIO_Port, G_Pin, SET);
	  	  break;
	  case 8:
	   	  HAL_GPIO_WritePin(A_GPIO_Port, A_Pin, RESET);
	   	  HAL_GPIO_WritePin(B_GPIO_Port, B_Pin, RESET);
	   	  HAL_GPIO_WritePin(C_GPIO_Port, C_Pin, RESET);
	   	  HAL_GPIO_WritePin(D_GPIO_Port, D_Pin, RESET);
	   	  HAL_GPIO_WritePin(E_GPIO_Port, E_Pin, RESET);
	   	  HAL_GPIO_WritePin(F_GPIO_Port, F_Pin, RESET);
	   	  HAL_GPIO_WritePin(G_GPIO_Port, G_Pin, RESET);
	   	  break;
	  case 9:
	   	  HAL_GPIO_WritePin(A_GPIO_Port, A_Pin, RESET);
	   	  HAL_GPIO_WritePin(B_GPIO_Port, B_Pin, RESET);
	  	  HAL_GPIO_WritePin(C_GPIO_Port, C_Pin, RESET);
	   	  HAL_GPIO_WritePin(D_GPIO_Port, D_Pin, RESET);
	   	  HAL_GPIO_WritePin(E_GPIO_Port, E_Pin, SET);
	   	  HAL_GPIO_WritePin(F_GPIO_Port, F_Pin, RESET);
	   	  HAL_GPIO_WritePin(G_GPIO_Port, G_Pin, RESET);
	   	  break;
	  }
  }
  void display7SEG_2(int num)
  {
  	  switch(num){
  	  case 0:
  		  HAL_GPIO_WritePin(A2_GPIO_Port, A2_Pin, RESET);
  		  HAL_GPIO_WritePin(B2_GPIO_Port, B2_Pin, RESET);
  		  HAL_GPIO_WritePin(C2_GPIO_Port, C2_Pin, RESET);
  		  HAL_GPIO_WritePin(D2_GPIO_Port, D2_Pin, RESET);
  		  HAL_GPIO_WritePin(E2_GPIO_Port, E2_Pin, RESET);
  		  HAL_GPIO_WritePin(F2_GPIO_Port, F2_Pin, RESET);
  		  HAL_GPIO_WritePin(G2_GPIO_Port, G2_Pin, SET);
  	   	  break;
  	  case 1:
  		  HAL_GPIO_WritePin(A2_GPIO_Port, A2_Pin, SET);
  		  HAL_GPIO_WritePin(B2_GPIO_Port, B2_Pin, RESET);
  		  HAL_GPIO_WritePin(C2_GPIO_Port, C2_Pin, RESET);
  		  HAL_GPIO_WritePin(D2_GPIO_Port, D2_Pin, SET);
  		  HAL_GPIO_WritePin(E2_GPIO_Port, E2_Pin, SET);
  		  HAL_GPIO_WritePin(F2_GPIO_Port, F2_Pin, SET);
  		  HAL_GPIO_WritePin(G2_GPIO_Port, G2_Pin, SET);
  	  	  break;
  	  case 2:
  		  HAL_GPIO_WritePin(A2_GPIO_Port, A2_Pin, RESET);
  		  HAL_GPIO_WritePin(B2_GPIO_Port, B2_Pin, RESET);
  		  HAL_GPIO_WritePin(C2_GPIO_Port, C2_Pin, SET);
  		  HAL_GPIO_WritePin(D2_GPIO_Port, D2_Pin, RESET);
  		  HAL_GPIO_WritePin(E2_GPIO_Port, E2_Pin, RESET);
  		  HAL_GPIO_WritePin(F2_GPIO_Port, F2_Pin, SET);
  		  HAL_GPIO_WritePin(G2_GPIO_Port, G2_Pin, RESET);
  	  	  break;
  	  case 3:
  		  HAL_GPIO_WritePin(A2_GPIO_Port, A2_Pin, RESET);
  		  HAL_GPIO_WritePin(B2_GPIO_Port, B2_Pin, RESET);
  		  HAL_GPIO_WritePin(C2_GPIO_Port, C2_Pin, RESET);
  		  HAL_GPIO_WritePin(D2_GPIO_Port, D2_Pin, RESET);
  		  HAL_GPIO_WritePin(E2_GPIO_Port, E2_Pin, SET);
  		  HAL_GPIO_WritePin(F2_GPIO_Port, F2_Pin, SET);
  		  HAL_GPIO_WritePin(G2_GPIO_Port, G2_Pin, RESET);
  	  	  break;
      case 4:
 		  HAL_GPIO_WritePin(A2_GPIO_Port, A2_Pin, SET);
 		  HAL_GPIO_WritePin(B2_GPIO_Port, B2_Pin, RESET);
 		  HAL_GPIO_WritePin(C2_GPIO_Port, C2_Pin, RESET);
 		  HAL_GPIO_WritePin(D2_GPIO_Port, D2_Pin, SET);
 		  HAL_GPIO_WritePin(E2_GPIO_Port, E2_Pin, SET);
 		  HAL_GPIO_WritePin(F2_GPIO_Port, F2_Pin, RESET);
 		  HAL_GPIO_WritePin(G2_GPIO_Port, G2_Pin, RESET);
  	   	  break;
  	  case 5:
  		  HAL_GPIO_WritePin(A2_GPIO_Port, A2_Pin, RESET);
  		  HAL_GPIO_WritePin(B2_GPIO_Port, B2_Pin, SET);
  		  HAL_GPIO_WritePin(C2_GPIO_Port, C2_Pin, RESET);
  		  HAL_GPIO_WritePin(D2_GPIO_Port, D2_Pin, RESET);
  		  HAL_GPIO_WritePin(E2_GPIO_Port, E2_Pin, SET);
  		  HAL_GPIO_WritePin(F2_GPIO_Port, F2_Pin, RESET);
  		  HAL_GPIO_WritePin(G2_GPIO_Port, G2_Pin, RESET);
  	   	  break;
  	  case 6:
  		  HAL_GPIO_WritePin(A2_GPIO_Port, A2_Pin, RESET);
  		  HAL_GPIO_WritePin(B2_GPIO_Port, B2_Pin, SET);
  		  HAL_GPIO_WritePin(C2_GPIO_Port, C2_Pin, RESET);
  		  HAL_GPIO_WritePin(D2_GPIO_Port, D2_Pin, RESET);
  		  HAL_GPIO_WritePin(E2_GPIO_Port, E2_Pin, RESET);
  		  HAL_GPIO_WritePin(F2_GPIO_Port, F2_Pin, RESET);
  		  HAL_GPIO_WritePin(G2_GPIO_Port, G2_Pin, RESET);
  	  	  break;
  	  case 7:
  		  HAL_GPIO_WritePin(A2_GPIO_Port, A2_Pin, RESET);
  		  HAL_GPIO_WritePin(B2_GPIO_Port, B2_Pin, RESET);
  		  HAL_GPIO_WritePin(C2_GPIO_Port, C2_Pin, RESET);
  		  HAL_GPIO_WritePin(D2_GPIO_Port, D2_Pin, SET);
  		  HAL_GPIO_WritePin(E2_GPIO_Port, E2_Pin, SET);
  		  HAL_GPIO_WritePin(F2_GPIO_Port, F2_Pin, SET);
  		  HAL_GPIO_WritePin(G2_GPIO_Port, G2_Pin, SET);
  	  	  break;
  	  case 8:
  		  HAL_GPIO_WritePin(A2_GPIO_Port, A2_Pin, RESET);
  		  HAL_GPIO_WritePin(B2_GPIO_Port, B2_Pin, RESET);
  		  HAL_GPIO_WritePin(C2_GPIO_Port, C2_Pin, RESET);
  		  HAL_GPIO_WritePin(D2_GPIO_Port, D2_Pin, RESET);
  		  HAL_GPIO_WritePin(E2_GPIO_Port, E2_Pin, RESET);
  		  HAL_GPIO_WritePin(F2_GPIO_Port, F2_Pin, RESET);
  		  HAL_GPIO_WritePin(G2_GPIO_Port, G2_Pin, RESET);
  	   	  break;
  	  case 9:
  		  HAL_GPIO_WritePin(A2_GPIO_Port, A2_Pin, RESET);
  		  HAL_GPIO_WritePin(B2_GPIO_Port, B2_Pin, RESET);
  		  HAL_GPIO_WritePin(C2_GPIO_Port, C2_Pin, RESET);
  		  HAL_GPIO_WritePin(D2_GPIO_Port, D2_Pin, RESET);
  		  HAL_GPIO_WritePin(E2_GPIO_Port, E2_Pin, SET);
  		  HAL_GPIO_WritePin(F2_GPIO_Port, F2_Pin, RESET);
  		  HAL_GPIO_WritePin(G2_GPIO_Port, G2_Pin, RESET);
  	   	  break;
  	  }
  }
  void display7SEG_set()
  {
	  HAL_GPIO_WritePin(A_GPIO_Port, A_Pin, SET);
  	  HAL_GPIO_WritePin(B_GPIO_Port, B_Pin, SET);
  	  HAL_GPIO_WritePin(C_GPIO_Port, C_Pin, SET);
      HAL_GPIO_WritePin(D_GPIO_Port, D_Pin, SET);
  	  HAL_GPIO_WritePin(E_GPIO_Port, E_Pin, SET);
  	  HAL_GPIO_WritePin(F_GPIO_Port, F_Pin, SET);
  	  HAL_GPIO_WritePin(G_GPIO_Port, G_Pin, SET);
  }
  void LED_set()
  {
	  HAL_GPIO_WritePin(LED_RED_GPIO_Port, LED_RED_Pin, SET);
	  HAL_GPIO_WritePin(LED_YELLOW_GPIO_Port, LED_YELLOW_Pin, SET);
	  HAL_GPIO_WritePin(LED_GREEN_GPIO_Port, LED_GREEN_Pin, SET);
	  HAL_GPIO_WritePin(LED_RED2_GPIO_Port, LED_RED2_Pin, SET);
	  HAL_GPIO_WritePin(LED_YELLOW2_GPIO_Port, LED_YELLOW2_Pin, SET);
	  HAL_GPIO_WritePin(LED_GREEN_GPIO_Port, LED_GREEN_Pin, SET);
  }
  int signl_X = 3;
  int signl_Y = 1;
  int counter_X = 3;
  int counter_Y = 5;
  LED_set();
  display7SEG_set();
  while (1)
  {
    /* USER CODE END WHILE */
	  switch(signl_X)
	  {
	  case 1:
		  display7SEG_2(counter_X--);
		  HAL_GPIO_WritePin(LED_YELLOW2_GPIO_Port, LED_YELLOW2_Pin, SET);
		  HAL_GPIO_WritePin(LED_RED2_GPIO_Port, LED_RED2_Pin, RESET);
		  if(counter_X < 0)
		  {
			  counter_X = 3;
			  signl_X = 3;
		  }
		  break;
	  case 2:
		  display7SEG_2(counter_X--);
		  HAL_GPIO_WritePin(LED_GREEN2_GPIO_Port, LED_GREEN2_Pin, SET);
		  HAL_GPIO_WritePin(LED_YELLOW2_GPIO_Port, LED_YELLOW2_Pin, RESET);
		  if(counter_X < 0)
		  {
			  counter_X = 5;
			  signl_X = 1;
		  }
		  break;
	  case 3:
		  display7SEG_2(counter_X--);
		  HAL_GPIO_WritePin(LED_RED2_GPIO_Port, LED_RED2_Pin, SET);
		  HAL_GPIO_WritePin(LED_GREEN2_GPIO_Port, LED_GREEN2_Pin, RESET);
		  if(counter_X < 0)
		  {
			  counter_X = 2;
			  signl_X = 2;
		  }
		  break;
	  }
//*****************************************************//
	  switch(signl_Y)
	  {
	  case 1:
		  display7SEG(counter_Y--);
		  HAL_GPIO_WritePin(LED_YELLOW_GPIO_Port, LED_YELLOW_Pin, SET);
		  HAL_GPIO_WritePin(LED_RED_GPIO_Port, LED_RED_Pin, RESET);
		  if(counter_Y < 0)
		  {
			  counter_Y = 3;
			  signl_Y = 3;
		  }
		  break;
	  case 2:
		  display7SEG(counter_Y--);
		  HAL_GPIO_WritePin(LED_GREEN_GPIO_Port, LED_GREEN_Pin, SET);
		  HAL_GPIO_WritePin(LED_YELLOW_GPIO_Port, LED_YELLOW_Pin, RESET);
		  if(counter_Y < 0)
		  {
			  counter_Y = 5;
			  signl_Y = 1;
		  }
		  break;
	  case 3:
	  	 display7SEG(counter_Y--);
    	 HAL_GPIO_WritePin(LED_RED_GPIO_Port, LED_RED_Pin, SET);
	  	 HAL_GPIO_WritePin(LED_GREEN_GPIO_Port, LED_GREEN_Pin, RESET);
	     if(counter_Y < 0)
	     {
	  	      counter_Y = 2;
	  		  signl_Y = 2;
	  	 }
	     break;
	   }
	  HAL_Delay(1000);
  }
}

void SystemClock_Config(void)
{
  RCC_OscInitTypeDef RCC_OscInitStruct = {0};
  RCC_ClkInitTypeDef RCC_ClkInitStruct = {0};

  /** Initializes the RCC Oscillators according to the specified parameters
  * in the RCC_OscInitTypeDef structure.
  */
  RCC_OscInitStruct.OscillatorType = RCC_OSCILLATORTYPE_HSI;
  RCC_OscInitStruct.HSIState = RCC_HSI_ON;
  RCC_OscInitStruct.HSICalibrationValue = RCC_HSICALIBRATION_DEFAULT;
  RCC_OscInitStruct.PLL.PLLState = RCC_PLL_NONE;
  if (HAL_RCC_OscConfig(&RCC_OscInitStruct) != HAL_OK)
  {
    Error_Handler();
  }
  /** Initializes the CPU, AHB and APB buses clocks
  */
  RCC_ClkInitStruct.ClockType = RCC_CLOCKTYPE_HCLK|RCC_CLOCKTYPE_SYSCLK
                              |RCC_CLOCKTYPE_PCLK1|RCC_CLOCKTYPE_PCLK2;
  RCC_ClkInitStruct.SYSCLKSource = RCC_SYSCLKSOURCE_HSI;
  RCC_ClkInitStruct.AHBCLKDivider = RCC_SYSCLK_DIV1;
  RCC_ClkInitStruct.APB1CLKDivider = RCC_HCLK_DIV1;
  RCC_ClkInitStruct.APB2CLKDivider = RCC_HCLK_DIV1;

  if (HAL_RCC_ClockConfig(&RCC_ClkInitStruct, FLASH_LATENCY_0) != HAL_OK)
  {
    Error_Handler();
  }
}

static void MX_GPIO_Init(void)
{
  GPIO_InitTypeDef GPIO_InitStruct = {0};

  /* GPIO Ports Clock Enable */
  __HAL_RCC_GPIOA_CLK_ENABLE();
  __HAL_RCC_GPIOB_CLK_ENABLE();

  /*Configure GPIO pin Output Level */
  HAL_GPIO_WritePin(GPIOA, LED_RED_Blinky_Pin|LED_YELLOW_Blinky_Pin|LED_RED_Pin|LED_YELLOW_Pin
                          |LED_GREEN_Pin|LED_RED2_Pin|LED_YELLOW2_Pin|LED_GREEN2_Pin, GPIO_PIN_RESET);

  /*Configure GPIO pin Output Level */
  HAL_GPIO_WritePin(GPIOB, A_Pin|B_Pin|C_Pin|D2_Pin
                          |E2_Pin|F2_Pin|G2_Pin|D_Pin
                          |E_Pin|F_Pin|G_Pin|A2_Pin
                          |B2_Pin|C2_Pin, GPIO_PIN_RESET);

  /*Configure GPIO pins : LED_RED_Blinky_Pin LED_YELLOW_Blinky_Pin LED_RED_Pin LED_YELLOW_Pin
                           LED_GREEN_Pin LED_RED2_Pin LED_YELLOW2_Pin LED_GREEN2_Pin */
  GPIO_InitStruct.Pin = LED_RED_Blinky_Pin|LED_YELLOW_Blinky_Pin|LED_RED_Pin|LED_YELLOW_Pin
                          |LED_GREEN_Pin|LED_RED2_Pin|LED_YELLOW2_Pin|LED_GREEN2_Pin;
  GPIO_InitStruct.Mode = GPIO_MODE_OUTPUT_PP;
  GPIO_InitStruct.Pull = GPIO_NOPULL;
  GPIO_InitStruct.Speed = GPIO_SPEED_FREQ_LOW;
  HAL_GPIO_Init(GPIOA, &GPIO_InitStruct);

  /*Configure GPIO pins : A_Pin B_Pin C_Pin D2_Pin
                           E2_Pin F2_Pin G2_Pin D_Pin
                           E_Pin F_Pin G_Pin A2_Pin
                           B2_Pin C2_Pin */
  GPIO_InitStruct.Pin = A_Pin|B_Pin|C_Pin|D2_Pin
                          |E2_Pin|F2_Pin|G2_Pin|D_Pin
                          |E_Pin|F_Pin|G_Pin|A2_Pin
                          |B2_Pin|C2_Pin;
  GPIO_InitStruct.Mode = GPIO_MODE_OUTPUT_PP;
  GPIO_InitStruct.Pull = GPIO_NOPULL;
  GPIO_InitStruct.Speed = GPIO_SPEED_FREQ_LOW;
  HAL_GPIO_Init(GPIOB, &GPIO_InitStruct);

}

void Error_Handler(void)
{
  __disable_irq();
  while (1)
  {
  }
}

/************************ (C) COPYRIGHT STMicroelectronics *****END OF FILE****/
